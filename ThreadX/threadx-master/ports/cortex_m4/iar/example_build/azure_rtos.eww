<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\relefererx_ELF74\Lab5\Lab5.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sample_threadx.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tx.ewp</path>
    </project>
    <batchBuild />
</workspace>
